Commit message: Update camera functionalities

File: assets/dexterity/cameras/realsense_d405/realsense_d405.urdf (robot description, URDF)
Before this commit: robot realsense_d405, 3 links, 2 joints
Links:
- link case: geometry visual mesh filename=assets/case.stl
