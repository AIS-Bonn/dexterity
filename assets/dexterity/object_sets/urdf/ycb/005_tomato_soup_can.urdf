Commit message: Update object lift params.

File: assets/dexterity/object_sets/urdf/ycb/005_tomato_soup_can.urdf (robot description, URDF)
Before this commit: robot 005_tomato_soup_can, 1 links, 0 joints
Links:
- link base_link: mass 0.32 -> 0.2
